Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-SRPFX-50333-001-model.ifc
Time: 2026-09-03T23:23:33+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-SRPFX-50333-001 Оборудование МГН «Тематический комплекс «Полицейская машина»»
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-SRPFX-50333-001; ModelReference: Оборудование МГН «Тематический комплекс «Полицейская машина»»; ProductionYear: 2026
